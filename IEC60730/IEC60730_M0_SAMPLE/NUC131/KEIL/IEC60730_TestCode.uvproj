# Keil uVision project IEC60730_TestCode.uvproj, settings and files
target IEC60730_TestCode (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: NUC131LC2AE Nuvoton
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0x8FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: IEC60730_ClassB_Test
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=5
  c define: NUC131
  c include: ..\..\..\..\Library\Device\Nuvoton\NUC131\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\CMSIS\Include;..\..\..\IEC60730_M0_STL;..\post-build;..\..\;.\;..\..\..\IEC60730_M0_Sample\NUC131\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x9000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\iec60730.sct
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC131/Source/: system_NUC131.c
    ../../../../Library/Device/Nuvoton/NUC131/Source/ARM/: startup_NUC131.s
  group User
    ../: main.c system_init.c
  group Library
    ../../../../Library/StdDriver/src/: adc.c clk.c fmc.c gpio.c i2c.c retarget.c sys.c timer.c uart.c wdt.c
  group IEC60730_SAFETY_TEST_LIB
    ../../../IEC60730_M0_STL/: ram_march_test.c ram_marchx_wom_test_startup.s ram_marchc_wom_test_startup.s ram_marchc_wom_test_runtime.s pc_test_startup.c stack_test_runtime.c cpureg_test_runtime.s cpureg_test_startup.s interrupt_test_runtime.c flash_test_startup.c flash_test_runtime.c stack_overrun_ptrn.c adc_mux_test_runtime.c global_var.c global_var_backup.c
  group IEC60730_SAFETY_CONTROL
    ../../../IEC60730_M0_STL/: CLASSB_TESTLIB_INIT.c CLASSB_STARTUP_TESTS.c CLASSB_RUNTIME_TESTS.c IEC60730_SAFETY_TEST_LIB.h IEC60730_SAFETY_TEST_LIB.c
